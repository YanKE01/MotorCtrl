# Keil uVision project LX_FOC.uvprojx, settings and files
target PMSM_FOC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LCM32F037 LCMicroelectronics
  pack: Keil.LCM32F0xx_DFP.0.4.58
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCM_RAM_V1 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\Headers\User_Includes;..\Headers\LCM32F03x_Drivers;..\Headers\User_Sources;..\Headers\Motor_Drivers\Basic;..\Headers\Motor_Drivers\Sensorless;..\Headers\Motor_Drivers\Algorithm;..\Headers\ARM_Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User/Main
    ../Sources/User_Main/: User_Main.c
  group User/Sources
    ../Sources/User_Soruces/: User_NVIC.c User_ADSample.c User_Interrupt.c User_PeripheralInit.c User_SysErrorProcess.c User_SysParaInit.c User_Usart.c User_DataTransform.c
  group MotorDrive/Basic
    ../Sources/Motor_Drivers/Basic/: MDS_CalcVoltage.c MDS_ClarkPark.c MDS_PIDRegulators.c MDS_SVPWM.c MDS_ThetaGenerate.c
  group MotorDrive/Algorithm
    ../Sources/Motor_Drivers/Algorithm/: MDS_MotorControl.c MDS_FluxWeakeningPowerControl.c
    ../Sources/Motor_Drivers/Sensorless/: MDS_CORDIC.c
  group UserHeaders
    ../Headers/User_Includes/: UserGlobals.h UserGlobalsType.h UserIncludes.h UserParaSetDefine.h UserParaSetDefineTemp.h
  group UserSourcesHeaders
    ../Headers/User_Sources/: User_ADSample.h User_Interrupt.h User_NVIC.h User_PeripheralInit.h User_SysErrorProcess.h User_SysParaInit.h User_Usart.h User_DataTransform.h
  group MotorDriveHeaders
    ../Headers/Motor_Drivers/Algorithm/: MDS_MotorControl.h MDS_FluxWeakeningPowerControl.h
    ../Headers/Motor_Drivers/Basic/: IQmathLib.h MDS_CalcVoltage.h MDS_ClarkePark.h MDS_PIDRegulators.h MDS_SVPWM.h MDS_ThetaGenerate.h
    ../Headers/Motor_Drivers/Sensorless/: MDS_Observer.h
  group LCM32FDriveSources
    ../Sources/LCM32F03x_Drivers/: lcm32f037_gpio.c lcm32f037_dma.c lcm32f037_iwdg.c lcm32f037_adc.c lcm32f037_ssp.c lcm32f037_wwdg.c lcm32f037_flash.c lcm32f037_exti.c lcm32f037_eeprom.c lcm32f037_uart.c lcm32f037_opa.c lcm32f037_acmp.c lcm32f037_dac.c lcm32f037_pwr.c lcm32f037_tim.c lcm32f037_rcc.c lcm32f037_timebase.c lcm32f037_startup.s lcm32f037_system.c
  group LCM32FDriveHeaders
    ../Headers/LCM32F03x_Drivers/: define.h lcm32f037_gpio.h lcm32f037_dma.h lcm32f037_iwdg.h lcm32f037_adc.h lcm32f037_ssp.h lcm32f037_wwdg.h lcm32f037_flash.h lcm32f037_exti.h lcm32f037_eeprom.h lcm32f037_uart.h lcm32f037_opa.h lcm32f037_acmp.h lcm32f037_dac.h lcm32f037_pwr.h lcm32f037_tim.h lcm32f037_rcc.h lcm32f037_type.h lcm32f037_lib.h lcm32f037_it.h
  group LCM32FDeviceHeaders
    ../Headers/ARM_Include/: anactrl.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h coproc.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h lcm32f037.h lcm32f037_conf.h system_lcm32f037.h
  group Lib
    ../Sources/User_Lib/: LCM_FOC_V374.lib
  group HY
    ../Sources/User_Soruces/: HY_Application.c HY_Variable.c HY_SoftIIC.c HY_Hal.c HY_Display.c
