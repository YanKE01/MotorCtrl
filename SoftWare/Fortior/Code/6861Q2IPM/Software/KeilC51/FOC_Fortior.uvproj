# Keil uVision project FOC_Fortior.uvproj, settings and files
target FU68XX_FOC (MCS-51)
  device: FU6812 Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: BingXiangYaSuoJiCode +hex
  c flags: Optimize=5 SizeSpeed=1
  c include: ..\FU68xx_Hardware_Driver\Include;..\User\Include
  link misc: REMOVEUNUSED
  group Apllication
    ../User/Source/Application/: main.c AddFunction.c Interrupt.c
    ../User/Include/: Customer.h Develop.h Protect.h
  group Function
    ../User/Source/Function/: MotorControl.c MotorControlFunction.c MotorProtect.c CurrentDecoupledControl.LIB DQCurrentKpKiCal.LIB LowSpeedObserver.LIB Mtpa.LIB TORQUE.LIB FiledWeaken.LIB
  group Hardware
    ../User/Source/Hardware/: AMPInit.c DriverInit.c EXTIInit.c TimerInit.c ADCInit.c CMPInit.c GPIOInit.c MDUInit.c PIInit.c UARTInit.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: FU68xx_2_System.c FU68xx_2_DMA.c STARTUP_FU6802.A51
  group Document
    ../Document/: DebugLog.txt Versionlog.txt
