# Keil uVision project FOC_Fortior.uvproj, settings and files
target FU68XX_FOC (MCS-51)
  device: FU68XX Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FOC_Fortior +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Include;..\FU68xx_Hardware_Driver\Include
  link misc: REMOVEUNUSED
  group Apllication
    ../User/Source/Application/: main.c Interrupt.c AddFunction.c MyFunction.c MyVariable.c
    ../User/Include/: Customer.h Protect.h Develop.h
  group Function
    ../User/Source/Function/: MotorControlFunction.c MotorControl.c MotorProtect.c BEMFDetect.c RSDDetect.c StartupInitandSwitch.c
    ../FU68xx_Hardware_Driver/Source/: Startup.LIB
  group Hardware
    ../User/Source/Function/: PID.c
    ../User/Source/Hardware/: ADC.c AMP.c CMP.c Driver.c EXTI.c GPIO.c MDU.c PI.c SPI.c Timer.c UART.c TM1650.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: FU68xx_2_DMA.c FU68xx_2_System.c STARTUP_FU6802.A51
  group Document
    ../: Readme.md
