# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LCM32F037 LCMicroelectronics
  pack: Keil.LCM32F0xx_DFP.0.4.55
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Device\Include;..\..\Driver\inc;G:\客户问题汇总\新建文件夹 (2)
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ReadMe
    ./: ReadME.txt
  group usr
    ../../../TIM1/TIM1_Brake_LVD/: main.c
  group startup
    ../../Device/Source/ARM/: lcm32f037_startup.s
    ../../Driver/src/: lcm32f037_acmp.c lcm32f037_adc.c lcm32f037_dac.c lcm32f037_dbgmcu.c lcm32f037_div.c lcm32f037_dma.c lcm32f037_eeprom.c lcm32f037_exti.c lcm32f037_flash.c lcm32f037_gpio.c lcm32f037_i2c.c lcm32f037_iwdg.c lcm32f037_opa.c lcm32f037_pwr.c lcm32f037_rcc.c lcm32f037_ssp.c lcm32f037_tim.c lcm32f037_uart.c lcm32f037_wwdg.c lcm32f037_I2cEmulation.c lcm32f037_wt.c lcm32f037_crc.c
    ../../Device/Source/: lcm32f037_system.c
